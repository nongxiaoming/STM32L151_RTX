# Keil uVision project project.uvproj, settings and files
target blink_led (ARM-ADS)
  device: STM32L151VD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: blink_led
  AfterMake: fromelf --bin !L --output blink_led.bin
  c flags: Optim=1
  c define: STM32L1XX_HD,USE_STDPERIPH_DRIVER,__RTX,__V3,VECT_TAB_OFFSET=0x00
  c include: ..\Drivers;.\Applications;..\Common\CMSIS\Include;..\Common\CMSIS\Device\ST\STM32L1xx\Include;..\Common\STM32L1xx_StdPeriph_Driver\inc;..\Common\RTX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications
    ./Applications/: main.c board.c led_task.c
  group Drivers
    ../Drivers/: led.c stm32l1xx_it.c power.c RTX_Config.c SVC_Table.s console.c iwdg.c beep.c
  group CMSIS
    ../Common/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../Common/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_hd.s
  group STM32L1xx_StdPeriph_Driver
    ../Common/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group RTX
    ../Common/RTX/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
